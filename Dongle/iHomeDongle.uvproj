# Keil uVision project iHomeDongle.uvproj, settings and files
target iHomeDongle (MCS-51)
  device: nRFLU1P-F16 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: iHomeDongle +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: NRF24LU1P
  c include: hal;hal\nrf24l01p;gazell\common;gazell\nrf24lu1;params;lib\crypt;lib\assertions;hal\nrf24lu1p;compiler\c51;compiler\common;app
  link misc: REMOVEUNUSED
  group app
    ./: STARTUP.A51
    ./app/: main.c usb_desc.c usb_hid_desc.c usb_func.c
  group gzll
    ./gazell/nrf24lu1/: gzll_mcu.c gzll_radio_isr.c gzll_timer_isr.c
    ./gazell/common/: gzll.c
  group hal
    ./hal/: hal_delay.c
    ./hal/nrf24lu1p/: hal_aes.c hal_nrf_hw.c hal_usb.c hal_usb_hid.c
    ./hal/nrf24l01p/: hal_nrf.c
  group lib
    ./lib/crypt/: lib_crypt.c lib_crypt_lu1.c
